# Keil uVision project DPI_Desktop_Tester_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: DPI_Desktop_Tester_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h SDA.c SDA.h SDA_aliases.h SCL.c SCL.h SCL_aliases.h RST_1.c RST_1.h RST_1_aliases.h MISO.c MISO.h MISO_aliases.h MOSI.c MOSI.h MOSI_aliases.h SCLK.c SCLK.h SCLK_aliases.h CS.c CS.h CS_aliases.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h HMC5883L_I2C.c HMC5883L_I2C.h HMC5883L_I2C_BOOT.c HMC5883L_I2C_INT.c HMC5883L_I2C_PM.c HMC5883L_I2C_SLAVE.c HMC5883L_I2C_MASTER.c HMC5883L_I2C_PVT.h LIS331HH_SPI.c LIS331HH_SPI.h LIS331HH_SPI_PM.c LIS331HH_SPI_INT.c LIS331HH_SPI_PVT.h LIS331HH_SPI_IntClock.c LIS331HH_SPI_IntClock.h CONFIG_COM.c CONFIG_COM.h CONFIG_COM_PM.c CONFIG_COM_INT.c CONFIG_COM_BOOT.c DATA_COM.c DATA_COM.h DATA_COM_PM.c DATA_COM_INT.c DATA_COM_BOOT.c CONFIG_COM_IntClock.c CONFIG_COM_IntClock.h DATA_COM_IntClock.c DATA_COM_IntClock.h HMC5883L_I2C_IntClock.c HMC5883L_I2C_IntClock.h
target Release (MCS-51)
  device: CY8C3866AXI-040 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0xFFFF) CLOCK(67000000) MODDP2"
  output: DPI_Desktop_Tester_PSoC3lib (library)
  c flags: Optimize=8
  c define: NDEBUG
  c misc: PR(${OutputDir}\${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: NDEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst)
  asm include: .;.\Generated_Source\PSoC3
  link misc: IX CODE RU
